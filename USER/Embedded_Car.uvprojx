# Keil uVision project Embedded_Car.uvprojx, settings and files
target Embedded_Car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Embedded_Car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --no_multibyte_chars
  c include: ..\CMSIS;..\FWLIB\inc;..\Main;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\timer;..\HARDWARE\Core_Board\MALLOC;..\HARDWARE;..\HARDWARE\Task_Board;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\HARDWARE\Task_Board\BH1705;..\HARDWARE\Task_Board\INFARED;..\HARDWARE\Task_Board\SYN7318;..\HARDWARE\Task_Board\ULTRASONIC;..\HARDWARE\Core_Board\POWER_CHECK;..\HARDWARE\Core_Board\UART;..\HARDWARE\Core_Board\UART\UART_A72;..\HARDWARE\Core_Board\RC522;..\APP\Movement;..\APP\Movement\A_Star;..\APP\Movement\PID;..\APP\Movement\ROAD_CHECK;..\APP\Debug;..\APP\Task;..\APP\CAN_TIMER;..\APP\Protocol;..\APP\Route;..\APP\AGV;..\APP\Data_Interaction;..\APP\my_lib;..\HARDWARE\Task_Board\AnalogSwitch;..\HARDWARE\Task_Board\SevenSegmentDisplay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c
  group APP
    ../APP/Movement/PID/: pid.c
    ../APP/AGV/: agv.c
    ../APP/Task/: task.c independent_task.c
    ../APP/Route/: route.c
    ../APP/Movement/A_Star/: a_star.c
    ../APP/Debug/: debug.c
    ../APP/Protocol/: protocol.c
    ../APP/CAN_TIMER/: can_timer.c
    ../APP/Movement/: movement.c
    ../APP/Movement/ROAD_CHECK/: roadway_check.c
    ../APP/Data_Interaction/: data_interaction.c
  group HARDWARE
    ../HARDWARE/Task_Board/: tba.c
    ../HARDWARE/Core_Board/: cba.c
    ../HARDWARE/Task_Board/SYN7318/: voice.c
    ../HARDWARE/Core_Board/RC522/: RC522.C
    ../HARDWARE/Core_Board/MALLOC/: malloc.c
    ../HARDWARE/Task_Board/INFARED/: infrared.c
    ../HARDWARE/Task_Board/BH1705/: bh1750.c
    ../HARDWARE/Core_Board/UART/: uart_drv.c
    ../HARDWARE/Core_Board/UART/UART_A72/: uart_a72.c
    ../HARDWARE/: hardware.c
    ../HARDWARE/Task_Board/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/Core_Board/POWER_CHECK/: power_check.c
    ../HARDWARE/Task_Board/AnalogSwitch/: analog_switch.c
    ../HARDWARE/Task_Board/SevenSegmentDisplay/: seven_segment_display.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: Timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
    ../FWLIB/src/: stm32f4xx_usart.c
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c
  group My_lib
    ../APP/my_lib/: data_filtering.c my_lib.c calculator.c
  group Doc
    ../: README.md
